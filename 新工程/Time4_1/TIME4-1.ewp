# IAR project TIME4-1.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S005K6 STM8S005K6
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: stm8s005k6
  ICCSTM8.CCIncludePath2: $PROJ_DIR$; FWLib\library\inc; FWLib\library\src
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: TIME4-1.hex
  ILINK.IlinkOutputFile: TIME4-1.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group (top)
    ./: stm8s_it.h
  group APP
    SRC/: main.c sys_config.c
  group BSP
    SRC/: bsp_flash.c bsp_ht1621b.c bsp_key.c bsp_uart.c stm8s_it.c temp_sensor.c
  group LIB
    FWLib/library/src/: stm8s_adc1.c stm8s_awu.c stm8s_beep.c stm8s_clk.c stm8s_exti.c stm8s_flash.c stm8s_gpio.c stm8s_i2c.c stm8s_it.h stm8s_itc.c stm8s_iwdg.c stm8s_rst.c stm8s_spi.c stm8s_tim1.c stm8s_tim2.c stm8s_tim3.c stm8s_tim4.c stm8s_uart2.c stm8s_wwdg.c
