<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>STM8</name>
    </toolchain>
    <debug>1</debug>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>STM8</name>
    </toolchain>
    <debug>0</debug>
  </configuration>
  <group>
    <name>APP</name>
    <file>
      <name>$PROJ_DIR$\SRC\main.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\SRC\sys_config.c</name>
    </file>
  </group>
  <group>
    <name>BSP</name>
    <file>
      <name>$PROJ_DIR$\SRC\bsp_flash.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\SRC\bsp_ht1621b.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\SRC\bsp_key.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\SRC\bsp_uart.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\SRC\stm8s_it.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\SRC\temp_sensor.c</name>
    </file>
  </group>
  <group>
    <name>LIB</name>
    <file>
      <name>$PROJ_DIR$\FWLib\library\src\stm8s_adc1.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\FWLib\library\src\stm8s_awu.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\FWLib\library\src\stm8s_beep.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\FWLib\library\src\stm8s_clk.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\FWLib\library\src\stm8s_exti.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\FWLib\library\src\stm8s_flash.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\FWLib\library\src\stm8s_gpio.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\FWLib\library\src\stm8s_i2c.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\FWLib\library\src\stm8s_it.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\FWLib\library\src\stm8s_itc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\FWLib\library\src\stm8s_iwdg.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\FWLib\library\src\stm8s_rst.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\FWLib\library\src\stm8s_spi.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\FWLib\library\src\stm8s_tim1.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\FWLib\library\src\stm8s_tim2.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\FWLib\library\src\stm8s_tim3.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\FWLib\library\src\stm8s_tim4.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\FWLib\library\src\stm8s_uart2.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\FWLib\library\src\stm8s_wwdg.c</name>
    </file>
  </group>
  <file>
    <name>$PROJ_DIR$\stm8s_it.h</name>
  </file>
</project>


